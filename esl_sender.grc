options:
  parameters:
    author: Steffen Robertz
    generate_options: no_gui
    id: esl_sender_full
    output_language: python
    run_options: run
    title: esl sender full
  states: {}

blocks:
- name: bt
  id: variable
  parameters:
    value: fsk_deviation_hz/data_samp_rate
  states: {}
- name: data_samp_rate
  id: variable
  parameters:
    value: '175000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2100000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*fsk_deviation_hz/samp_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: round(samp_rate/data_samp_rate)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*fsk_deviation_hz/samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from configparser import Interpolation
      from random import sample
      from tkinter.filedialog import Open
      import numpy as np
      from gnuradio import gr
      import pmt
      import hexdump
      import math


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, input_file=None, packet_length=23, silence_samples=0, interpolation=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Wakeup Signal Source',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.single]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.packet_length = packet_length
              if input_file != None:
                  self.input_file = open(input_file,'rb')
              self.silence_samples = silence_samples
              self.silence_samples_missing = 0 
              self.bytes_read = 0
              self.interpolation = interpolation

          def work(self, input_items, output_items):
              #handle first call
              if self.nitems_written(0) == 0:
                   self.add_item_tag(0, 0, pmt.intern("Burst"), pmt.intern("SOB"))
              
              #Handle missing silence samples first:
              if self.silence_samples_missing:
                  samples_to_transmit = min(len(output_items[0]), self.silence_samples_missing)
                  #print("Going to transmit {} silence samples".format(samples_to_transmit))
                  append_array = np.zeros(samples_to_transmit, dtype=float)
                  output_items[0][:samples_to_transmit] = append_array
                  self.silence_samples_missing -= samples_to_transmit
                  return samples_to_transmit
              
              current_bytes_read = 0
              for i in range(0,math.floor((math.floor(len(output_items[0])/8)/self.interpolation))):
                  frame_byte = self.input_file.read(1)
                  if len(frame_byte) == 0:
                      return i*8
                  for j in range(0,8):
                      data = -1.0
                      if (frame_byte[0]&(1<<(7-j)))>>(7-j):
                          #transmit 1
                          data = 1.0
                      output_items[0][i*8+j:i*8+j+self.interpolation] = np.full(self.interpolation, data)
                  current_bytes_read += 1
                  self.bytes_read += 1 
                  if self.bytes_read % self.packet_length == 0:
                      #Add silence samples
                      #print("Read {} bytes".format(self.bytes_read))
                      self.silence_samples_missing = self.silence_samples
                      #set end of busrt (EOB), to last bit
                      self.add_item_tag(0, self.nitems_written(0)+current_bytes_read*8*self.interpolation+3, pmt.intern("Burst"), pmt.intern("EOB"))
                      #set start of burst (SOB)
                      self.add_item_tag(0, self.nitems_written(0)+(current_bytes_read*8+self.silence_samples)*self.interpolation, pmt.intern("Burst"), pmt.intern("SOB"))
                      #print("Adding silence into leftover space")
                      samples_to_transmit = min(len(output_items[0])-(current_bytes_read*8*self.interpolation), self.silence_samples_missing)
                      #print("GHoing to add {} silence bytes".format(samples_to_transmit))
                      append_array = np.zeros(samples_to_transmit, dtype=float)
                      output_items[0][current_bytes_read*8:current_bytes_read*8+samples_to_transmit] = append_array
                      self.silence_samples_missing -= samples_to_transmit
                      return current_bytes_read*8 + samples_to_transmit
              return current_bytes_read*8*self.interpolation
    input_file: '"/tmp/wakeup_in"'
    interpolation: '1'
    packet_length: '23'
    silence_samples: '0'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import cmath


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, ):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Mute non burst samples',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.received_eob = False


          def work(self, input_items, output_items):
              #print("New iteration")
              mute_areas = []
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key)
                  value = pmt.to_python(tag.value)
                  if key == 'Burst' and value == 'EOB':
                      self.received_eob = True
                      #print("EOB at: {}".format(tag.offset))
                      mute_areas.append([tag.offset-self.nitems_written(0),len(input_items[0])])
                  elif key == 'Burst' and value == 'SOB':
                      #print("SOB at: {}".format(tag.offset))
                      self.received_eob = False
                      if len(mute_areas) == 0:
                          mute_areas.append([0,0])
                      index = tag.offset-self.nitems_written(0)
                      mute_areas[-1][1] = index

              if len(tags) == 0 and self.received_eob:
                  #Everything is muted
                  mute_areas.append([0,len(input_items[0])])
              
              output_items[0][:] = input_items[0][:]
              #print(mute_areas)
              for start,stop in mute_areas:
                  for i in range(start, stop):
                      #print("muting")
                      output_items[0][i] = cmath.rect(0, cmath.phase(input_items[0][i]))
              #print("Produced: {}".format(len(input_items[0])))
              return len(input_items[0])
  states: {state: disabled}
- name: esl_img_source_0
  id: esl_img_source
  parameters:
    file_path: ''
    height: '103'
    name: Image Source
    samp_rate: samp_rate
    tag_id: int(0x05b6b6)
    width: '215'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: '[1.0370673503984351e-12,1.4448351369489298e-11,1.7457865708614406e-10,1.82947135218825e-09,1.6627293319970704e-08,1.3106269136642368e-07,8.959796673480014e-07,5.312253506417619e-06,2.731624226726126e-05,0.00012182170758023858,0.000471183389890939,0.0015805811854079366,0.004598383326083422,0.011602593585848808,0.025390228256583214,0.04818807914853096,0.07931844145059586,0.11323229968547821,0.14019353687763214,0.150538370013237,0.14019353687763214,0.11323229968547821,0.07931844145059586,0.04818807914853096,0.025390228256583214,0.011602593585848808,0.004598383326083422,0.0015805811854079366,0.000471183389890939,0.00012182170758023858,2.731624226726126e-05,5.312253506417619e-06,8.959796673480014e-07,1.3106269136642368e-07,1.6627293319970704e-08,1.82947135218825e-09,1.7457865708614406e-10,1.4448351369489298e-11,1.0370673503984351e-12,6.455906230613817e-14]'
    type: fff
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=000000000000000075b068dc321a7307"'
    bb_gain0: '0'
    bw0: samp_rate
    freq0: '433260000'
    gain0: '14'
    if_gain0: '48'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', osmosdr_sink_0, '0']
- [esl_img_source_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
