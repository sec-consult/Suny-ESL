options:
  parameters:
    generate_options: qt_gui
    id: esl_decoder
    output_language: python
    title: ESL Decoder
  states: {}

blocks:
- name: bt
  id: variable
  parameters:
    value: fsk_deviation_hz/data_samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '433254000'
  states: {}
- name: data_samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: modulated_preamble
  id: variable_modulate_vector
  parameters:
    data: sync_header
    mod: digital.gfsk_mod(sps,sensitivity,bt)
    taps: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*fsk_deviation_hz/samp_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: round(samp_rate/data_samp_rate)
  states: {}
- name: sync_header
  id: variable
  parameters:
    value: '[0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa]'
  states: {}
- name: ted_bw
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    start: '0'
    step: '0.0001'
    stop: '0.01'
    value: '0.003'
  states: {}
- name: ted_dampening
  id: variable_qtgui_range
  parameters:
    label: Dampening
    start: '0'
    step: '0.1'
    stop: '3'
    value: '1'
  states: {}
- name: ted_deviation
  id: variable_qtgui_range
  parameters:
    label: deviation
    start: '0'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0.0001'
    step: '0.05'
    stop: '2'
    value: '0.15'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '0'
    sps: sps
    symbols: modulated_preamble
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: ted_dampening
    loop_bw: ted_bw
    max_dev: ted_deviation
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '8'
    samp_rate: '8000000'
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '130000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '30000'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1234'
    type: UDP_CLIENT
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=000000000000000075b068dc321a7307"'
    bb_gain0: '20'
    bw0: '8000000'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: '8000000'
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0_3_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Error
    label2: T_inst
    label3: T_avg
    name: Error
    nconnections: '3'
    size: '1024'
    srate: data_samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: ''
    type: float
  states: {}
- name: reveng_srb_packet_deframer_0
  id: reveng_srb_packet_deframer
  parameters:
    fixed_len: 'False'
    max_len: '75'
    name: deframer
    pack_bytes: 'True'
    pkt_len: 63*8
    pkt_len_adj: '2'
    pkt_len_offset: '0'
    sync: '[x.to_bytes(1,''big'') for x in list(map(int, bin(0xd391d391)[2:].zfill(32)))]'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_threshold_ff_1, '0']
- [blocks_add_const_vxx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_threshold_ff_1, '0', blocks_multiply_const_vxx_0, '0']
- [digital_binary_slicer_fb_0, '0', reveng_srb_packet_deframer_0, '0']
- [digital_corr_est_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_0_3_0, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_0_3_0, '1']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_0_3_0, '2']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', digital_corr_est_cc_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [reveng_srb_packet_deframer_0, out, blocks_message_debug_0, print_pdu]
- [reveng_srb_packet_deframer_0, out, network_socket_pdu_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
